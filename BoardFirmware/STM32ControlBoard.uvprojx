# Keil uVision project STM32ControlBoard.uvprojx, settings and files
target Stm32Board (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32ControlBoard +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X
  c include: .;.\aes\inc;.\USB-FS\inc;.\Firmware\inc;.\rsa\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Main Group
    ./: main.c
  group aes
    ./aes/src/: aes_dec.c aes_enc.c aes_invsbox.c aes_keyschedule.c aes_sbox.c aes128_dec.c aes128_enc.c aes192_dec.c aes192_enc.c aes256_dec.c aes256_enc.c gf256mul.c aes_blocks_dec.c aes_blocks_enc.c
  group USB-FS
    ./USB-FS/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group Firmware
    ./Firmware/src/: hw_config.c usb_desc.c usb_pwr.c usb_prop.c usb_istr.c usb_endp.c stm32_it.c usb_flash.c mytrng.c transport_layer.c
    ./rsa/lib/: STM32CryptographicV3.0.0_CM3_KEIL_otslsm1elfspf.lib
    ./Firmware/inc/: transport_layer.h
software components: CMSIS:CORE 5.2.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:CRC 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0
